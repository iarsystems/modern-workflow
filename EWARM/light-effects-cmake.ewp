# IAR project light-effects-cmake.ewp, settings and files
configuration Debug (CMake_ARM, debug)
  General.OGChipSelectEditMenu: STM32F429II ST STM32F429II
  General.CoreVariant: 39
  General.FPU2: 4
configuration Release (CMake_ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
configuration RelWithDebInfo (CMake_ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
configuration MinSizeRel (CMake_ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 38
  General.FPU2: 0
  group (top)
    ../: CMakeLists.txt
  group CMakeFiles/cmake
    ../cmake/: ielftool.cmake
  group CMakeFiles/CppUTest/src/CppUTest
    ../CppUTest/src/CppUTest/: CMakeLists.txt
  group CMakeFiles/Drivers
    ../Drivers/: CMakeLists.txt
  group CMakeFiles/EWARM
    ./: CMakeLists.txt
  group CMakeFiles/Src
    ../Src/: CMakeLists.txt
  group CMakeFiles/Src/testcode
    ../Src/testcode/: CMakeLists.txt
  group CppUTest [Library]/CppUTest/src/CppUTest
    ../CppUTest/src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp JUnitTestOutput.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleMutex.cpp SimpleString.cpp TeamCityTestOutput.cpp TestFailure.cpp TestFilter.cpp TestHarness_c.cpp TestMemoryAllocator.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp TestTestingFixture.cpp Utest.cpp
  group CppUTest [Library]/CppUTest/src/Platforms/Iar
    ../CppUTest/src/Platforms/Iar/: UtestPlatform.cpp
  group light-effects [Executable]/Drivers/STM32F4xx_HAL_Driver/Src
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_adc.c
  group light-effects [Executable]/EWARM
    ./: startup_stm32f429xx.s
  group light-effects [Executable]/Src
    ../Src/: adc.c crc.c dac.c dma.c gpio.c led.c lights.cpp main.cpp spi.c stm32f429ii_aca.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c stm32f4xx_it.c system_stm32f4xx.c
  group light-effects [Executable]/Src/testcode
    ../Src/testcode/: bm_search.cpp bubble_sort.cpp linear_search.cpp simple_search.cpp
